# IAR project RTU.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: ADC12.c AT24C04.c AT45DB041D.c ATConfig.c CPASCII.c Display.c ds18b20.c IIC.c LishiData.c main.c Menu.c MSP430_hardware.c PCF8563.c Public.c Rainfall.c RS485.c RTU.c ST7920.c ST7920code.c system.c UART_Library.c
